# Keil uVision project jang.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: jang
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\led;.\beep;.\key;.\usart;.\exti;.\fir_key_beep;.\systick;.\DHT11;.\iic;.\at24c02;.\OLED;.\u8g2;.\spi;.\fatfs;.\FRTOS_CORE;.\My_FreeRTOS;.\srf05;.\esp01;.\MQTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./user/: main.c all_interupt_handle.c
  group led
    ./led/: my_led.c my_led.h
  group beep
    ./beep/: my_beep.c my_beep.h
  group key
    ./key/: my_key.c my_key.h
  group fir
    ./fir/: my_fir.c my_fir.h
  group usart
    ./usart/: my_usart.c my_usart.h
  group exti
    ./exti/: my_exti.c my_exti.h
  group fir_key_beep
    ./fir_key_beep/: my_system.c my_system.h
  group systick
    ./systick/: my_systick.c my_systick.h
  group dht11
    ./DHT11/: my_dht11.c my_dht11.h dht11_tim2.c dht11_tim2.h
  group iic
    ./iic/: my_iic.c my_iic.h
  group at24c02
    ./at24c02/: my_at24c02.c my_at24c02.h
  group oled
    ./OLED/: my_oled.c my_oled.h
  group u8g2
    ./u8g2/: mui.c mui.h mui_u8g2.c mui_u8g2.h u8g2.h u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8.h u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group spi
    ./spi/: my_spi.c my_spi.h w25q64.c w25q64.h
  group fatfs
    ./fatfs/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group FRTOS_CORE
    ./FRTOS_CORE/: atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOSConfig.h heap_4.c list.c list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h tasks.c timers.c timers.h
  group My_FreeRTOS
    ./My_FreeRTOS/: my_task_create.c my_freertos_fun.h
  group srf05
    ./srf05/: my_srf05.c my_srf05.h
  group esp01
    ./esp01/: esp01_usart2.c esp01_usart2.h LOOP_BUFF.c LOOP_BUFF.h
  group MQTT
    ./MQTT/: MQTT.c MQTT.h mqtt_interface.c mqtt_interface.h
software components: CMSIS:CORE 5.0.1, Device:Startup 1.3.1, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
